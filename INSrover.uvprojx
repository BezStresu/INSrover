# Keil uVision project INSrover.uvprojx, settings and files
target FRDM-KL05ZJ (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: MKL05Z32xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.1
  cpu: IRAM(0x1FFFFC00,0x00001000) IROM(0x00000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: INSrover
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x1ffffc00 size 0x1000
  group src
    ./: main.c pit.c ADC.c led.c lcd1602.c uart.c i2c.c control.c functions.c
  group inc
    ./: frdm_bsp.h pit.h ADC.h main.h led.h lcd1602.h uart.h i2c.h control.h functions.h
  group test
    ./: adc_done.txt acc_done.txt fun.txt test1.txt acc_done_2.txt test2.txt working1.txt half_working.txt
software components: CMSIS:CORE 5.6.0, CMSIS:DSP 1.14.2, Device:Startup 1.0.0
